v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/tmp/kustinj/ee272bclone/lvs/tsmc_bandgap_real_lvs.sym} 200 -30 0 0 {name=x1}
