v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/tmp/kustinj/ee272bclone/lvs/currentMirrorGold.sym} 90 -40 0 0 {name=x1}
