v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/tmp/kustinj/ee272bclone/lvs/ampcurrentsource.sym} 160 -30 0 0 {name=x1}
